# Keil uVision project SDIO_CMSIS.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SDIO_CMSIS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  asm include: .\fatfs;.\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/Src/: main.c initscript.c
  group fatfs
    ./fatfs/: ff.c diskio.c ffsystem.c ffunicode.c
  group SDIO
    ./SDIO/Src/: sdio.c
  group CMSIS_DELAY
    ./CMSIS_DELAY/Src/: cmsis_delay.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
